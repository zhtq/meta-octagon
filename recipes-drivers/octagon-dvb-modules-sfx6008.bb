KV = "4.4.176"
SRCDATE = "20220929"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "78fe5b7ab9def55de42e2154053ec6f8"
SRC_URI[sha256sum] = "ebfe93b43d032de24bc4954e2d367a3fbf18a7fe8b984483b968462b9df70397"

