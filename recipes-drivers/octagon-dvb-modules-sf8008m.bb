KV = "4.4.35"
SRCDATE = "20201218"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "1df450b35fa7922c2d55d43d22599a9e"
SRC_URI[sha256sum] = "84d33718780d9f5d7fd68ba1d63de0ba196fffe03f63912826f763ba307adc58"

